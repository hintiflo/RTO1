# Keil uVision project Apus.uvprojx, settings and files
target Apus (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F072VBHx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Apus +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072,USE_STDPERIPH_DRIVER,USE_USB_DEVICE_FS,INTERNAL_PULLUP
  c include: .\src;.\system\stm32f0-stdperiph;.\src\Devices;.\src\USB;.\src\CLibrarys;.\src\ioLibrary_Driver\Ethernet;.\src\ioLibrary_Driver\Internet;.\src\ff12c\src;.\src\Tasks
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group BSP
    ./src/BSP/: Key.c Led.c TftDisplay.c Adc.c systick.c
  group OS
    ./src/: main.c APOS.c APOS.s APOS.h
  group ST-Lib
    ./system/stm32f0-stdperiph/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Devices
    ./src/Devices/: startup_stm32f072.s system_stm32f0xx.c
  group Fonts
    ./src/Fonts/: TftFont_6x8.c TftFont_16x24.c
  group Tasks
    ./src/Tasks/: TaskCounter.c TaskKey.c TaskLed.c TaskMandelbrot.c TaskPoti.c TaskWatch.c TestTask.h TestTask.c
